options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 100e3
    stop: 6000e6
    value: 102.9e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: power
  id: variable_qtgui_label
  parameters:
    type: real
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
