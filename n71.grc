options:
  parameters:
    generate_options: qt_gui
    id: n71
    output_language: python
    title: n71
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 100e3
    stop: 6000e6
    value: 680e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: power
  id: variable_qtgui_label
  parameters:
    type: real
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 35e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_probe_avg_mag_sqrd_x_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '1'
    threshold: '0'
    type: cf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}

connections:
- [analog_probe_avg_mag_sqrd_x_0, '0', qtgui_number_sink_0, '0']
- [osmosdr_source_0, '0', analog_probe_avg_mag_sqrd_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
